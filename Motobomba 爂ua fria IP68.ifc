Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [ContentGUID: 79fc7846-b8bd-4a55-b49c-b72764612d86, VersionGUID: 7d4c1af0-3382-4ef9-aafe-f79cb3261d05, NumberOfSaves: 1], CoordinateReference [CoordinateBase: Coordenadas compartilhadas, ProjectSite: Terreno padrão]
File name: Motobomba água fria IP68.ifc
Time: 2025-02-02T15:18:49-03:00
Author: Marcilio Henrique M. Santos, eng.henrique@outlook.com
Organization: Map Projetos Inteligentes
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.0.13 (PTB) - IFC 24.3.0.13

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm (6)
Outros - Categoria: Níveis; Família: Nível; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: 349; Tipo: Cabeça de 8 mm
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no
Outros(Tipo) - Categoria: Níveis; Nome da família: Nível
Restrições(Tipo) - Base da elevação: Ponto base do projeto
Gráficos(Tipo) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes
Dados de identidade(Tipo) - Nome do tipo: Cabeça de 8 mm
Name | LongName = Nome | Elevation (mm) = Elevação (mm)
Sapata B.O. | Sapata B.O. | -4600
Sapata T.O. | Sapata T.O. | -4300
Laje T.O. | Laje T.O. | -4000
Parede da fundação T.O. | Parede da fundação T.O. | -300
Nível 1 | Nível 1 | 0
Nível 2 | Nível 2 | 4000

# IfcBuildingElementProxy: Motobomba água fria IP68:1/4cv - 220v, Motobomba água fria IP68:1/4cv - 220v:325233
In: Nível 1
Type - Material: Aço Inox, Plástico prego - Syllent
Type - Outros - Categoria: Equipamento mecânico; Nome da família: Motobomba água fria IP68
Type - Restrições - Elevação padrão: 0 mm
Type - Dados - Tabela: Água fria IP68
Type - Cotas - Comprimento: 210 mm; DN - Recalque: 32 mm; DN - Sucção: 32 mm; l1: 5 mm; l2: 71 mm; l3: 80.3 mm; l4: 10 mm; l5: 10 mm; l6: 1.3 mm; m: 2 mm; r1: 1.7 mm; r2: 6 mm; Raio 1: 4.5 mm; Rre: 20 mm; Rri: 16 mm
Type - Geral - Data de criação: Janeiro de 2025; e-mail de contato:: eng.henrique@outlook.com; Família produzida por:: Marcilio Henrique M. Santos
Type - Dados de identidade - Descrição: Motobomba de circulação de água fria IP 68 1/4cv Monofásica 220v; Fabricante: Syllent; Modelo: MB63E0081AS 1; Nome do tipo: 1/4cv - 220v; Número OmniClass: 23.60.30.21.17; Título OmniClass: Motor Pumps; URL: https://www.syllent.com.br/produto-bomba-agua-fria-circulacao
Type - Materiais e acabamentos - Carenagem: Plástico prego - Syllent; Tampa frontal: Plástico prego - Syllent
Type - Mecânica - Classificação: Bomba
Type - Pset_ManufacturerTypeInformation - Manufacturer: Syllent
Pset_BuildingElementProxyCommon - Reference: Motobomba água fria IP68:1/4cv - 220v; sets with these values: 2
Quantidade de equipamento mecânico - Descrição da unidade: Motobomba água fria IP68; Tipo: 1/4cv - 220v; Descrição: Motobomba de circulação de água fria IP 68 1/4cv Monofásica 220v; Fabricante: Syllent; Modelo: MB63E0081AS 1; URL: https://www.syllent.com.br/produto-bomba-agua-fria-circulacao
Outros - Família: Motobomba água fria IP68; Família e tipo: Motobomba água fria IP68: 1/4cv - 220v; ID de tipo: 325217; Tipo: 1/4cv - 220v
Restrições - Deslocamento do hospedeiro: 0 mm; Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível 1
Cotas - Área: 0.190656 m2; Volume: 0.00345495 m3
Dados de identidade - Corrente: 2.4 A; Descrição do Material: Motobomba de circulação de água fria IP 68 1/4cv Monofásica 220v; Fator de potência: 0.99; Frequência: 60 Hz; Marca: 4; Peso: 4.6 kg; Potência: 180 W; Pressão máx.: 159000 Pa; Pressão máx. na sucção: 80000 Pa; Proteção: IP 68; Temperatura máx. da água: 45 C; Temperatura mín. da água: 5 C; Tensão: 220 V
Mecânica - Classificação do sistema: Não definido
Fases - Fase criada: Fase 1

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
InPort_325233_1 | SINK
OutPort_325233_2 | SOURCE
